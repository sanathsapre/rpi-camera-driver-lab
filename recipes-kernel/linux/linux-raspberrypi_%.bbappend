FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://video-builtin.cfg"
